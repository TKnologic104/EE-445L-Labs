# Keil uVision project Lab3_Clock.uvproj, settings and files
target ADCSWTrigger (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ADCSWTrigger
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s ADCSWTrigger.c PLL.c ST7735.c ST7735.h main.c Title.c Timer.c Speaker.c LCD.c Switches.c Switches.h
